# Keil uVision project NRF_to_USBcdc.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: NUC240SE3AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.7
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: NRF_to_USBcdc
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\include;..\libraries\Official\CMSIS\Include;..\libraries\Official\Device\Nuvoton\NUC230_240\Include;..\libraries\Official\StdDriver\inc;..\libraries\User\inc
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group CMSIS
    ../libraries/Official/Device/Nuvoton/NUC230_240/Source/: system_NUC230_240.c
    ../libraries/Official/Device/Nuvoton/NUC230_240/Source/ARM/: startup_NUC230_240.s
  group Libraries_Official
    ../libraries/Official/StdDriver/src/: clk.c gpio.c retarget.c rtc.c spi.c sys.c uart.c usbd.c
  group Libraries_User
    ../libraries/User/src/: vMemAlloc.c NRF24L01.c NRF_P2P.c fifo.c
  group Source
    ../Source/: main.c project.c portable.c irq.c descriptors.c cdc_serial.c
